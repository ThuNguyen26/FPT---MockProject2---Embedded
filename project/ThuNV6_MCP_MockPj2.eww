<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ThuNV6_MCP_MockPj2.ewp</path>
    </project>
    <batchBuild />
</workspace>
